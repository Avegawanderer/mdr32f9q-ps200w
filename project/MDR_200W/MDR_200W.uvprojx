# Keil uVision project MDR_200W.uvprojx, settings and files
target RAM (ARM-ADS)
  device: MDR1986BE92 Milandr
  pack: Keil.MDR1986BExx.1.4
  cpu: IROM(0x08000000,0x20000) IRAM(0x20000000,0x8000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: MDR_200W
  c flags: Optim=1
  c include: .\;.\src;.\src\fonts;..\Library\Libraries\CMSIS\CM3\DeviceSupport\MDR32F9Qx\inc;..\Library\Libraries\CMSIS\CM3\DeviceSupport\MDR32F9Qx\startup\arm;..\Library\Libraries\MDR32F9Qx_StdPeriph_Driver\inc;..\Library\FreeRTOSV7.5.3\FreeRTOS\Source\portable\RVDS\ARM_CM3\;..\Library\FreeRTOSV7.5.3\FreeRTOS\Source;..\Library\FreeRTOSV7.5.3\FreeRTOS\Source\include
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group CMSIS
    ../../source/: startup_MDR32F9x.s
    ../../library/CMSIS/CM3/DeviceSupport/MDR32F9Qx/startup/arm/: system_MDR32F9Qx.c
    ../../library/CMSIS/CM3/CoreSupport/: core_cm3.c
  group StdPeriphLibrary
    ../../library/MDR32F9Qx_StdPeriph_Driver/src/: MDR32F9Qx_ssp.c MDR32F9Qx_port.c MDR32F9Qx_timer.c MDR32F9Qx_i2c.c MDR32F9Qx_adc.c MDR32F9Qx_uart.c MDR32F9Qx_dma.c MDR32F9Qx_rst_clk.c
  group FreeRTOS
    ../../source/: FreeRTOSConfig.h
    ../../library/FreeRTOS/Source/portable/RVDS/ARM_CM3/: port.c portmacro.h
    ../../library/FreeRTOS/Source/: croutine.c list.c queue.c tasks.c timers.c
    ../../library/FreeRTOS/Source/portable/MemMang/: heap_4.c
  group src
    ../../source/: main.c
    ../../source/src/: adc.c buttons.c control.c converter.c converter_hw.c dispatcher.c dwt_delay.c encoder.c guiTop.c i2c_eeprom.c lcd_1202.c led.c service.c sound_driver.c sound_samples.c systemfunc.c systick.c buttons_top.c uart_parser.c uart_rx.c uart_tx.c eeprom.c isr_user_handlers.c uart_hw.c uart_proto.c
  group gui
    ../../source/gui/: guiMainForm.c guiMasterPanel.c guiSetupPanel.c guiEditPanel1.c guiMessagePanel1.c guiEditPanel2.c
  group guiCore
    ../../source/gui/guiCore/: guiCore.c
  group guiWidgets
    ../../source/gui/guiWidgets/: guiCheckBox.c guiPanel.c guiSpinBox.c guiStringList.c guiTextLabel.c guiTextSpinBox.c guiRadioButton.c guiSelectTextBox.c
  group guiGraphics
    ../../source/gui/guiGraphics/: font_6x8_mono.c font_h10.c font_h10_bold.c font_h11.c font_h16.c font_h32.c guiGraphHAL.c guiGraphPrimitives.c guiGraphWidgets.c other_images.c widget_images.c
  group utils
    ../../source/gui/utils/: utils.c
target FLASH (ARM-ADS)
  device: MDR1986BE92 Milandr
  pack: Keil.MDR1986BExx.1.4
  cpu: as above
  output: MDR_200W +hex
  c flags: Optim=2
  c include: ..\..\source;..\..\source\src;..\..\source\gui;..\..\source\gui\guiCore;..\..\source\gui\guiWidgets;..\..\source\gui\guiGraphics;..\..\source\gui\utils;..\..\library\CMSIS\CM3\DeviceSupport\MDR32F9Qx\inc;..\..\library\CMSIS\CM3\DeviceSupport\MDR32F9Qx\startup\arm;..\..\library\MDR32F9Qx_StdPeriph_Driver\inc;..\..\library\FreeRTOS\Source\portable\RVDS\ARM_CM3;..\..\library\FreeRTOS\Source;..\..\library\FreeRTOS\Source\include;..\..\library\CMSIS\CM3\CoreSupport
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x8000
